.title KiCad schematic
.include "Cordell-Models.txt.lib"
J1 Net-_D3-Pad1_ Net-_D3-Pad1_ 0 0 0 0 0 0 Net-_D2-Pad2_ Net-_D2-Pad2_ Power In
D1 Net-_C1-Pad2_ KICK_TRIGGER 1N4148C
R1 Net-_C1-Pad2_ 0 100K
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 100n
R4 Net-_C1-Pad1_ Net-_Q2-Pad2_ 22K
R5 Net-_Q2-Pad2_ 0 10K
Q2 0 Net-_Q2-Pad2_ Net-_Q2-Pad3_ 2N3904C
Q3 ACCENT Net-_Q3-Pad2_ Net-_C7-Pad2_ 2N3906C
R8 Net-_Q3-Pad2_ Net-_Q2-Pad3_ 10K
R7 ACCENT Net-_Q3-Pad2_ 4K7
C7 Net-_C7-Pad1_ Net-_C7-Pad2_ 15n
R10 Net-_C7-Pad1_ Net-_C7-Pad2_ 100K
R11 0 Net-_C7-Pad1_ 4K7
U1 Net-_C10-Pad2_ Net-_C9-Pad1_ Net-_C7-Pad1_ -12V Net-_R19-Pad1_ Net-_R18-Pad2_ Net-_C11-Pad2_ +12V TL072
R12 Net-_C10-Pad2_ Net-_C9-Pad1_ 1Meg
D4 Net-_C7-Pad1_ 0 1N4148C
R2 Net-_Q1-Pad2_ Net-_C7-Pad2_ 8K2
R3 0 Net-_Q1-Pad2_ 2K7
Q1 0 Net-_Q1-Pad2_ Net-_C2-Pad2_ 2N3904C
R6 Net-_C2-Pad2_ +12V 1Meg
C2 0 Net-_C2-Pad2_ 100n
Q4 0 Net-_C2-Pad2_ Net-_C8-Pad1_ 2N3904C
R9 Net-_C8-Pad1_ +12V 22K
D3 Net-_D3-Pad1_ -12V BAT85C
D2 +12V Net-_D2-Pad2_ BAT85C
C6 -12V 0 100n
C5 0 +12V 100n
C3 +12V 0 47u
C4 0 -12V 47u
H1 0 MountingHole_Pad
H2 0 MountingHole_Pad
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ 33n
R14 Net-_R14-Pad1_ Net-_C8-Pad2_ 1Meg
D5 0 Net-_C8-Pad2_ 1N4148C
R17 Net-_C11-Pad2_ Net-_R14-Pad1_ 470K
R13 Net-_C9-Pad1_ Net-_C8-Pad1_ 100K
C9 Net-_C9-Pad1_ Net-_C10-Pad1_ 15n
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 15n
Q5 0 Net-_C9-Pad1_ Net-_Q5-Pad3_ 2N3904C
R15 Net-_C10-Pad1_ Net-_Q5-Pad3_ 5K9
R16 Net-_Q5-Pad3_ 0 47K
R18 Net-_C10-Pad2_ Net-_R18-Pad2_ 47K
R20 Net-_R18-Pad2_ Net-_C11-Pad2_ 47K
R19 Net-_R19-Pad1_ 0 22K
C11 Net-_C11-Pad1_ Net-_C11-Pad2_ 33u
RV1 Net-_R18-Pad2_ Net-_R18-Pad2_ Net-_C11-Pad1_ Decay 500K
R21 Net-_C10-Pad2_ Net-_R21-Pad2_ 220R
R22 Net-_R21-Pad2_ Net-_C12-Pad1_ 10K
RV2 Net-_R21-Pad2_ Net-_C12-Pad1_ Net-_C12-Pad1_ Tone 10K
C12 Net-_C12-Pad1_ 0 100n
C13 Net-_C13-Pad1_ Net-_C12-Pad1_ 0.47u
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 0.47u
R23 Net-_Q6-Pad2_ Net-_C14-Pad2_ 82K
R24 0 Net-_Q6-Pad2_ 100K
Q6 Net-_C15-Pad1_ Net-_Q6-Pad2_ +12V 2N3904C
R26 -12V Net-_C15-Pad1_ 5K9
C16 Net-_C15-Pad1_ 0 220p
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 1u
R27 KICK_OUT Net-_C15-Pad2_ 1K
R25 Net-_C15-Pad2_ 0 100K
J2 KICK_TRIGGER ACCENT 0 KICK_OUT Kick
.tran 1u 100m 0
.end
